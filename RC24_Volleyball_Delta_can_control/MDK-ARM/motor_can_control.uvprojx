# Keil uVision project motor_can_control.uvprojx, settings and files
target motor_can_control (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: motor_can_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Board/Include;../Motor_Drive/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../User_Tasks/Include;../Algorithm/Include;../Correspondence/Include;../Sensor/Include
  asm include: ../Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c beep.c
  group Board
    ../Board/src/: bsp.c bsp_tim.c bsp_can.c bsp_usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Sensor
    ../Sensor/Src/: Saber_Inertia.c briter_encoder.c Odometer.c Light.c
  group Correspondence
    ../Correspondence/Src/: AppData_Receive.c Scope_printf.c Vision_Receive.c Internal_Communication.c
  group Algorithm
    ../Algorithm/Src/: math_formula.c Path_Tracking.c pid.c wheel_calculation.c Path_Data.c Filter_Algorithm.c
  group Motor_Drive
    ../Motor_Drive/src/: HTM_5046.c GO_M8010_6.c DjiMotor.c vesc6.c Motor_Feedback.c TIM_Callback.c GIM4310_steadywin.c
  group User_Tasks
    ../User_Tasks/Src/: AppRemote_Task.c CushionBall_Task.c HitBall_Task.c ArmDrive_Task.c Vision_Task.c LightRemote_Task.c MotorText_task.c
software components: CMSIS:CORE 5.4.0
